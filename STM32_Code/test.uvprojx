# Keil uVision project test.uvprojx, settings and files
target LED实验 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Source\User\Main;.\Source\CMSIS\Core\CM3;.\Source\STM32F10x_StdPeriph_Driver\inc;.\HardWare\EC20;.\HardWare;.\SYSTEM\sys;.\SYSTEM\delay;.\HardWare\LCD;.\HardWare\RS485;.\HardWare\W25Q64
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./Source/User/Main/: main.c stm32f10x_it.c stm32f10x_conf.h
  group HardWaew
    ./HardWare/EC20/: EC20.c
    ./HardWare/LCD/: LCD.c
    ./HardWare/RS485/: RS485.c
    ./HardWare/W25Q64/: W25Q64.c
  group SYS
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
  group Library
    ./Source/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_usart.c misc.c
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group Documentation
    ./Source/Documentation/: 说明.txt
software components: CMSIS:CORE 4.3.0

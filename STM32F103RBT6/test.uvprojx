# Keil uVision project test.uvprojx, settings and files
target TESt (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Source\User;.\Source\CMSIS\Core\CM3;.\Source\STM32F10x_StdPeriph_Driver\inc;.\SYSTEM\sys;.\SYSTEM\delay;.\HardWare\EC20;.\HardWare
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./Source/User/: main.c stm32f10x_it.c
  group HardWare
    ./HardWare/EC20/: EC20.c
  group SYS
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group Library
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Documentation
    ./Source/Documentation/: 说明.txt
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 4.3.0
